# Keil uVision project ZepelinTranssmitter1.uvproj, settings and files
target Target (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ZepelinTranssmitter1 +hex
  AfterMake: fromelf --bin --output UVisionOutput/ZepelinTranssmitter1.bin UVisionOutput/ZepelinTranssmitter1.axf
  c flags: Optim=1
  c define: STM32F10X_MD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Source/: main.c STM32_Init.c SoftSpiPhy.c SpiControlBridge.c
    ./Source/CMSIS/: STM32F10x.s
  group CMSIS
    ./Source/CMSIS/: core_cm3.c system_stm32f10x.c
